# Keil uVision project smart_car.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: smart_car
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: _MSPM0G3507
  c include: ..\source\third_party\CMSIS\Core\Include;..\source
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\sct\mspm0g3507.sct
  group lib
    ./lib/: driverlib.a
  group user
    ./code/: empty.c empty.syscfg ti_msp_dl_config.c ti_msp_dl_config.h
    ../../mspm0_sdk_2_08_00_03/source/ti/devices/msp/m0p/startup_system_files/keil/: startup_mspm0g350x_uvision.s
